# Keil uVision project Am32G431.uvprojx, settings and files
target G431_test (6190000::V6.19::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AM32_REF_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: REF_G431, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: ..\Mcu\g431\Drivers\STM32G4xx_HAL_Driver\Inc;..\Mcu\g431\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Inc;..\Mcu\g431\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
  group startup
    ../Mcu/g431/Startup/: startup_stm32g431xx.s
  group Drivers
    ../Mcu/g431/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group Src
    ../Src/: dshot.c dshot_slow.c firmwareversion.c functions.c main.c signal.c sounds.c kiss_telemetry.c precharge_check.c
  group Mcu
    ../Mcu/g431/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32g4xx_it.c system_stm32g4xx.c WS2812.c
target PhotonDrive_G431 (6190000::V6.19::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: as above
  output: AM32_PROTONDRIVE_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: PROTONDRIVE_G431, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
software components: CMSIS:CORE 5.6.0
