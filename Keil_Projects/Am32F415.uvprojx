# Keil uVision project Am32F415.uvprojx, settings and files
target TEKKO32_F415 (6210000::V6.21::ARMCLANG)
  device: -AT32F415K8U7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AM32_TEKKO32_F415 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F415K8U7,USE_STDPERIPH_DRIVER, TEKKO32_F415
  c include: ..\Inc;..\mcu\F415\Inc;..\Mcu\f415\Drivers\drivers\inc;..\Mcu\f415\Drivers\CMSIS\cm4\core_support;..\Mcu\f415\Drivers\CMSIS\cm4\device_support
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\f415\Am32.sct
  group Startup
    ../Mcu/f415/Startup/mdk/: startup_at32f415.s
  group Src
    ../Src/: dshot.c dshot_slow.c functions.c main.c signal.c sounds.c firmwareversion.c
  group Drivers
    ../Mcu/f415/Drivers/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group F415
    ../Mcu/f415/Src/: ADC.c at32f415_it.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c system_at32f415.c
target AT32DEV_F415 (6190000::V6.19::ARMCLANG)
  device: -AT32F415K8U7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.4
  cpu: as above
  output: AM32_AT32DEV_F415 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F415K8U7,USE_STDPERIPH_DRIVER, AT32DEV_F415
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\f415\Am32.sct
target DAKEFPV_35A (6190000::V6.19::ARMCLANG)
  device: -AT32F415K8U7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.4
  cpu: as above
  output: AM32_DAKEFPV_35A_F415 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F415K8U7,USE_STDPERIPH_DRIVER, DAKEFPV_35A_F415
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\f415\Am32.sct
target MAMBA_F55_F415 (6190000::V6.19::ARMCLANG)
  device: -AT32F415K8U7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.4
  cpu: as above
  output: AM32_MAMBA_F55_F415 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F415K8U7,USE_STDPERIPH_DRIVER, MAMBA_F55_F415
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\f415\Am32.sct
